Properties of the parts of a building model (IFC4X3), part 2 of 2

Thermal - Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(6); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Density: 0 kg/m3; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-25mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Color: 8820953; Glow: no; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-25; Shininess: 64; Smoothness: 50; Transparency: 0

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-40
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(7); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-40mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-40; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-50
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(8); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-50mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-50; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-60
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(9); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-60mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-60; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-70
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(10); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-70; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-75
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(11); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-75mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-75; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-80
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(12); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-80; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-90
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(13); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-90; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-100
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(1); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-100mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-100; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-110
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(2); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-110mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-110; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-120
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(3); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-120mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-120; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-140
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(4); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-140mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-140; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-150
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard(5); Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Manufacturer: Kingspan Insulation Ltd; Model: K107-150mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-150; Shininess: 64; Smoothness: 50
