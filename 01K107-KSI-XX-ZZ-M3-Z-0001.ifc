Properties of the parts of a building model (IFC4X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 0727c0cf-70c0-4a3d-9536-3e94980fc3e1, NumberOfSaves: 8], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: 01K107-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-11T13:14:08+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K107

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K107; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K107; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_BuildingStoreyCommon - Reference: Level:Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Level:Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: Generic Models : Model Text : 600mm KI_CenturyGothic (13)
In: Level 0
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 600mm KI_CenturyGothic
Type - Text - Bold: no; Italic: no; Text Font: Century Gothic; Text Size: 600 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:600mm KI_CenturyGothic
Pset_EnvironmentalImpactIndicators - Reference: Model Text:600mm KI_CenturyGothic
Other - Family: Model Text; Family and Type: Model Text: 600mm KI_CenturyGothic; Type: 600mm KI_CenturyGothic; Type Id: 305799
Constraints - Work Plane: Level : Level 0
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Generic Models : Model Text :...) | Text
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 25mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 120mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 40mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 50mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 60mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 70mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 75mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 80mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 90mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 100mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 110mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 140mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K107 - 150mm

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 100 mm
Type - Dimensions - Length: 2400mm; Thickness: 100mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.100mm.BIM-1025.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-100mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.19 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.26316 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.19 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-100 100 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-100 100 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-100mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 100; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.100mm.BIM-1025.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-100; Type Id: 308915
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 100 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 100 mm; Volume: 0.288 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 110 mm
Type - Dimensions - Length: 2400mm; Thickness: 110mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.110mm.BIM-1026.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-110mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.172727 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.78947 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.172727 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-110 110 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-110 110 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-110mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 110; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.110mm.BIM-1026.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-110; Type Id: 308947
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 110 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 110 mm; Volume: 0.3168 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 120 mm
Type - Dimensions - Length: 2400mm; Thickness: 120mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.120mm.BIM-1027.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-120mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.158333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 6.31579 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.158333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-120 120 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-120 120 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-120mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 120; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.120mm.BIM-1027.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-120; Type Id: 308979
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 120 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 120 mm; Volume: 0.3456 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 140 mm
Type - Dimensions - Length: 2400mm; Thickness: 140mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.140mm.BIM-1028.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-140mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.135714 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 7.36842 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.135714 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-140 140 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-140 140 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-140mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 140; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.140mm.BIM-1028.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-140; Type Id: 309011
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 140 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 140 mm; Volume: 0.4032 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 150 mm
Type - Dimensions - Length: 2400mm; Thickness: 150mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.150mm.BIM-1029.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-150mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.126667 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 7.89474 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.126667 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-150 150 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-150 150 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-150mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 150; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.150mm.BIM-1029.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-150; Type Id: 309043
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 150 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 150 mm; Volume: 0.432 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 25 mm
Type - Dimensions - Length: 2400mm; Thickness: 25mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.25mm.BIM-1017.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-25mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.76 kg/K/s3; Roughness: 3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 1.31579 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.76 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-25 25 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-25 25 mm
Pset_CoveringCommon - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25; IsExternal: yes
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-25mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 25; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.25mm.BIM-1017.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-25; Type Id: 308473
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Maximum Ridge Height: 25 mm; Rafter Cut: Plumb Cut
Dimensions - Area: 2.88 m2; Slope: 0; Thickness: 25 mm; Volume: 0.072 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 40 mm
Type - Dimensions - Length: 2400mm; Thickness: 40mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.40mm.BIM-1018.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-40mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.475 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.10526 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.475 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-40 40 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-40 40 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-40mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 40; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.40mm.BIM-1018.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-40; Type Id: 308691
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 40 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 40 mm; Volume: 0.1152 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 50 mm
Type - Dimensions - Length: 2400mm; Thickness: 50mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.50mm.BIM-1019.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-50mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.38 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.63158 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.38 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-50 50 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-50 50 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-50mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 50; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.50mm.BIM-1019.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-50; Type Id: 308723
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 50 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 50 mm; Volume: 0.144 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 60 mm
Type - Dimensions - Length: 2400mm; Thickness: 60mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.60mm.BIM-1020.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-60mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.316667 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.15789 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.316667 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-60 60 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-60 60 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-60mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 60; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.60mm.BIM-1020.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-60; Type Id: 308755
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 60 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 60 mm; Volume: 0.1728 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 70 mm
Type - Dimensions - Length: 2400mm; Thickness: 70mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.70mm.BIM-1021.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-70mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.271429 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.68421 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.271429 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-70 70 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-70 70 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 70; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.70mm.BIM-1021.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-70; Type Id: 308787
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 70 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 70 mm; Volume: 0.2016 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 75 mm
Type - Dimensions - Length: 2400mm; Thickness: 75mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.75mm.BIM-1022.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-75mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.253333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.94737 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.253333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-75 75 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-75 75 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-75mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 75; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.75mm.BIM-1022.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-75; Type Id: 308819
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 75 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 75 mm; Volume: 0.216 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 80 mm
Type - Dimensions - Length: 2400mm; Thickness: 80mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.80mm.BIM-1023.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-80mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.2375 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.21053 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.2375 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-80 80 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-80 80 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 80; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.80mm.BIM-1023.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-80; Type Id: 308851
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 80 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 80 mm; Volume: 0.2304 m3
Phasing - Phase Created: New Construction

# IfcCovering: Roofs : Basic Roof : KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90
In: Level 0
Type - PredefinedType: INSULATION
Type - Other - Category: Roofs; Family Name: Basic Roof
Type - Construction - Default Thickness: 90 mm
Type - Dimensions - Length: 2400mm; Thickness: 90mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K107; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.90mm.BIM-1024.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K107-90mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.211111 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.73684 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.211111 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat); Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-90 90 mm; KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-90 90 mm
Pset_CoveringCommon - IsExternal: yes; Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90
Pset_EnvironmentalImpactIndicators - Reference: Basic Roof:KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90
Roof Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K107; Manufacturer: Kingspan Insulation Ltd; Type Comments: K107-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/roof-insulation-boards/kooltherm-k107-pitched-roof-board/; Description: Phenolic insulation for tiled or slated pitched warm roof spaces.; Assembly Code: n/a; Type Mark: n/a; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 2400mm; Width: 1200mm; Thickness: 90; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k107-gb-and-ireland/kingspan-kooltherm-k107-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K107.90mm.BIM-1024.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Roof; Family and Type: Basic Roof: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90; Type: KingspanInsulation_Insulation_Kooltherm-K107-PitchedRoofBoard-90; Type Id: 308883
Constraints - Base Level: Level 0; Base Offset From Level: 0 mm; Cutoff Offset: 0 mm; Related to Mass: no; Room Bounding: yes
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Maximum Ridge Height: 90 mm
Dimensions - Slope: 0; Area: 2.88 m2; Thickness: 90 mm; Volume: 0.2592 m3
Phasing - Phase Created: New Construction

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K107-PitchedRoofBoard-25
Identity - Class: Generic
